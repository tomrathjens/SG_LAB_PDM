Commit message: fixed the rotation problem

File: robots/full_assembly_robot_unit.urdf (robot description, URDF)
Before this commit: robot full_assembly_robot_unit, 7 links, 6 joints
Links:
- link UV_LED_link: mass None -> 0.001
- link sensor_camera_link: mass None -> 0.001
