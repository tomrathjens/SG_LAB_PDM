Commit message: changed the controller, so that each unit has own state memory

File: robots/ball1.urdf (robot description, URDF)
Before this commit: robot ball1, 1 links, 0 joints
Links:
- link baseLink: geometry collision sphere radius=0.003; visual sphere radius=0.003
